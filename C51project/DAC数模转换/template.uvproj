# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\APP\key;.\APP\iic;.\APP\at24c02;.\APP\ds18b20;.\APP\ds1302;.\APP\smg;.\APP\ired;.\APP\xpt2046;.\APP\pwm
  group User
    ./User/: main.c
  group APP
    ./APP/pwm/: pwm.c
  group Public
    ./Public/: public.c
