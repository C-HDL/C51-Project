# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\ds18b20;.\App_Demo
  group User
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/ds18b20/: ds18b20.c
  group Public
    ./Public/: public.c uart.c timer.c timer.h
  group App_Demo
    ./App_Demo/: wifi_control.c
